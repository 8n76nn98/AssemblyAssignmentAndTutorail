# Keil uVision project Lab-4-4-Anagram.uvproj, settings and files
target Simulation (ARM-ADS)
  device: LPC2468 NXP
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Lab-4-4-Anagram
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: .\lpc2468Flash.sct
  group Code
    ./: Lab-4-4-Anagram.s
target Hardware (Load to RAM) (ARM-ADS)
  device: LPC2468 NXP
  cpu: as above
  output: Lab-4-4-Anagram
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: .\lpc2468RAM.sct
target Hardware (Load to Flash) (ARM-ADS)
  device: LPC2468 NXP
  cpu: as above
  output: Lab-4-4-Anagram
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: .\lpc2468Flash.sct
